# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\System\inc;.\Hardware\inc;.\User\inc
  group System
    ./System/src/: delay.c uart.c
  group Hardware
    ./Hardware/src/: lcd1602.c button.c
  group User
    ./User/src/: main.c
